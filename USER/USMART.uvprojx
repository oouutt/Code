# Keil uVision project USMART.uvprojx, settings and files
target USMART (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USMART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\USMART;..\HARDWARE\OLED;..\HARDWARE\RTC;..\HARDWARE\ADC;..\HARDWARE\STMFLASH;..\HARDWARE\USART3;..\HARDWARE\TIME;..\Gizwits;..\Utils;..\HARDWARE\DS18B20;..\HARDWARE\LICENSE;..\HARDWARE\DHT11;..\HARDWARE\REMOTE;..\HARDWARE\BUJ;..\HARDWARE\USART2;..\HARDWARE\SYSSET;..\HARDWARE\HX711;..\HARDWARE\JR6001;..\HARDWARE\HC05
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIME/: Timer.c
    ../HARDWARE/RTC/: rtc.c stime.c dtime.c
    ../HARDWARE/BUJ/: BUJ.c
    ../HARDWARE/SYSSET/: sysset.c
    ../HARDWARE/HX711/: HX711.c
    ../HARDWARE/JR6001/: JR6001.c
    ../HARDWARE/HC05/: hc05.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: stm32f10x5_00.lib
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
